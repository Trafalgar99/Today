//循环点亮八个灯
    ORG 0000H
MAIN: MOV A, #1
LOOP: MOV P1, A
    ACALL DELAY
    RL A
    SJMP LOOP
DELAY:MOV R7, #20
DEL3: MOV R6, #200
DEL2: MOV R5, #125
DEL1: DJNZ R5, DEL1
    DJNZ R6, DEL2
    DJNZ R7, DEL3
    RET
    END

//亮1s 灭1s
    ORG 0000H
FLASH:MOV A, #1
FSH0: MOV R2, #0AH
FLOP: MOV P1, A
    LCALL DELAY
    MOV P1, #0
    LCALL DELAY
    DJNZ R2, FLOP
    RL A
    SJMP FSH0
DELAY:MOV R7, #20
DEL3: MOV R6, #200
DEL2: MOV R5, #125
DEL1: DJNZ R5, DEL1
    DJN  Z R6, DEL2
    DJNZ R7, DEL3
    RET
    END 


// 两边向中间
    ORG 0000H
BEGIN: MOV A, #81H
    MOV R2, #4

LOOP: MOV P1, A
    LCALL DELAY
    LCALL TOMID
    DJNZ R2, NEXT
    SJMP BEGIN
NEXT: SJMP LOOP


TOMID: PUSH A
    ANL A, #F0H
    RR A
    MOV R0, A
    POP A
    ANL A, #0FH
    RL A
    ADD A, R0
    RET 
DELAY:MOV R7, #20
DEL3: MOV R6, #200
DEL2: MOV R5, #125
DEL1: DJNZ R5, DEL1
    DJNZ R6, DEL2
    DJNZ R7, DEL3
    RET
    END 